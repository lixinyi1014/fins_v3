# Keil uVision project RM_Frame_C.uvprojx, settings and files
target RM_Frame_C (6240000::V6.24::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: RM_Frame_C +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -O2 -fno-fast-math -fno-finite-math-only
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\userCode\devices\Inc;..\userCode\algorithms\Inc;..\userCode\bsp\Inc;..\userCode\drivers\Inc;..\userCode\MiddleWares\Inc;../userCode/tasks/Inc;../Middlewares/Third_Party/FreeRTOS/include;../Middlewares/Third_Party/FreeRTOS/portable/GCC/ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c adc.c usart.c dma.c can.c i2c.c spi.c iwdg.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c system_stm32f4xx.c
  group Devices
    ../userCode/devices/Src/: IMU.cpp Extension.cpp Usermain.cpp Sensor.cpp Legacy.cpp Propeller.cpp Servo.cpp Watchdog.cpp LED.cpp Buzzer.cpp
  group Drivers
    ../userCode/drivers/Src/: BMI088driver.cpp ist8310driver.cpp
  group BSP
    ../userCode/bsp/Src/: bsp_spi.cpp
  group Middlewares
    ../userCode/MiddleWares/Src/: BMI088Middleware.cpp ist8310driver_middleware.cpp
  group Algorithms
    ../userCode/algorithms/Src/: MahonyAHRS.cpp PID.cpp Kalman_Filter.cpp Matrix.cpp
  group USB
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group New Group
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group FreeRTOS Runtime
    ../Src/: LowerTimebase.c
    ../userCode/tasks/Src/: ControllerTaskStartup.cpp ControlLoopTask.cpp ImuAttitudeTask.cpp PressurePwmTask.cpp UartTransmitTask.cpp TaskInterruptHandlers.cpp TaskSharedState.cpp I2cBusAccess.cpp
    ../Middlewares/Third_Party/FreeRTOS/: tasks.c queue.c list.c
    ../Middlewares/Third_Party/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Async acquisition and fused control
    ../userCode/algorithms/Src/: AttitudeEskf.cpp FusionConfiguration.cpp FusionTimeline.cpp PressureCompensation.cpp FusedController.cpp
    ../userCode/devices/Src/: ImuDmaAcquisition.cpp PressureArrayAcquisition.cpp FusedControlAdapter.cpp
    ../userCode/tasks/Src/: ImuFusionTask.cpp ImuSampleInterrupts.cpp
software components: CMSIS:CORE 5.0.1
