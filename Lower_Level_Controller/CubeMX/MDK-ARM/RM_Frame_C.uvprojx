# Keil uVision project RM_Frame_C.uvprojx, settings and files
target RM_Frame_C (6240000::V6.24::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: RM_Frame_C +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -O2 -fno-fast-math -fno-finite-math-only
  c include: ../../Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/CMSIS/Include;../../userCode/tasks/Inc;../../Middlewares/Third_Party/FreeRTOS/include;../../Middlewares/Third_Party/FreeRTOS/portable/GCC/ARM_CM4F;..\..\userCode\devices\Inc;..\..\userCode\algorithms\Inc;..\..\userCode\bsp\Inc;..\..\userCode\drivers\Inc;..\..\userCode\MiddleWares\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../../Src/: main.c gpio.c adc.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group FreeRTOS Runtime
    ../../Src/: LowerTimebase.c
    ../../userCode/tasks/Src/: ControllerTaskStartup.cpp ControlLoopTask.cpp ImuAttitudeTask.cpp PressurePwmTask.cpp UartTransmitTask.cpp TaskInterruptHandlers.cpp TaskSharedState.cpp I2cBusAccess.cpp
    ../../Middlewares/Third_Party/FreeRTOS/: tasks.c queue.c list.c
    ../../Middlewares/Third_Party/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Lower Controller Application
    ../../userCode/algorithms/Src/: Kalman_Filter.cpp MahonyAHRS.cpp Matrix.cpp PID.cpp
    ../../userCode/bsp/Src/: bsp_spi.cpp
    ../../userCode/devices/Src/: Buzzer.cpp Extension.cpp IMU.cpp LED.cpp Legacy.cpp Propeller.cpp Sensor.cpp Servo.cpp Usermain.cpp Watchdog.cpp
    ../../userCode/drivers/Src/: BMI088driver.cpp ist8310driver.cpp
    ../../userCode/MiddleWares/Src/: BMI088Middleware.cpp ist8310driver_middleware.cpp
  group Async acquisition and fused control
    ../../userCode/algorithms/Src/: AttitudeEskf.cpp FusedController.cpp FusionConfiguration.cpp FusionTimeline.cpp PressureCompensation.cpp
    ../../userCode/devices/Src/: FusedControlAdapter.cpp ImuDmaAcquisition.cpp PressureArrayAcquisition.cpp
    ../../userCode/tasks/Src/: ImuFusionTask.cpp ImuSampleInterrupts.cpp
software components: CMSIS:CORE 4.3.0
